#  HZ  S  MA  R  50.00
! Rohde & Schwarz Vector Network Analyzer
! Rohde-Schwarz,ZNL6-2Port,1323001206101378,1.50.1.34-21.10.1.104
! Created: UTC 2/26/2024, 3:38:06 AM
! freq[Hz]  mag:S11  ang:S11  mag:S21  ang:S21  mag:S12  ang:S12  mag:S22  ang:S22
! Worked out from all points (weakly coupled two-port):
!   5999 points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, 88.35 kHz to 500 MHz, reference 50 ohm
!   highest |S21| = -16.90 dB at 2.922 MHz (marker M1); lowest = -96.5 dB at 8.006 MHz (marker M2)
!   lowest |S11| = -75.3 dB at 16.26 MHz (marker M3), VSWR 1.00, Z = 50 + j0.00148 ohm
!   |S11| at or under -10 dB: 153.3 kHz to end of sweep
!   |S22| runs from -28.7 to -10.8 dB; largest |S21 - S12| = 0.15
!   S11 on the Smith chart (normalised r, x): 88.35 kHz: 0.97, +0.77; 90.44 MHz: 1.02, -0.03; 288 MHz: 0.78, -0.14; 500 MHz: 0.81, -0.35
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 88.35 kHz  -8.8  -53.5  -57.3  -10.8
! 2.922 MHz  -18.5  -16.9  -20.1  -18.0
! 8.006 MHz  -47.0  -96.5  -57.5  -27.0
! 16.26 MHz  -75.3  -54.1  -60.4  -27.1
! 24.18 MHz  -66.4  -71.9  -65.7  -27.4
! 39.18 MHz  -44.6  -58.8  -73.0  -27.6
! 83.43 MHz  -35.8  -59.7  -55.6  -27.1
! 90.44 MHz  -35.9  -76.3  -57.7  -26.6
! 116.5 MHz  -33.1  -54.6  -75.3  -27.0
! 130.2 MHz  -31.0  -73.9  -57.1  -27.7
! 136.4 MHz  -29.7  -56.4  -64.0  -28.2
! 140.7 MHz  -30.5  -61.2  -58.2  -27.2
! 166.8 MHz  -27.0  -66.5  -62.8  -27.2
! 250 MHz  -18.6  -53.1  -52.9  -26.0
! 288 MHz  -16.8  -47.2  -47.3  -26.5
! 302.6 MHz  -21.8  -45.3  -47.5  -25.9
! 316.1 MHz  -33.6  -47.1  -48.8  -26.1
! 333.4 MHz  -23.3  -49.0  -52.4  -26.3
! 368.3 MHz  -14.9  -50.4  -50.8  -25.1
! 393.6 MHz  -25.8  -57.0  -59.9  -25.0
! 416.7 MHz  -20.9  -53.9  -58.7  -25.7
! 500 MHz  -13.4  -45.0  -45.2  -24.8
