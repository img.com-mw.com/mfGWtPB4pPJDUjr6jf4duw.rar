#  HZ  S  MA  R  50.00
! Rohde & Schwarz Vector Network Analyzer
! Rohde-Schwarz,ZNL6-2Port,1323001206101378,1.50.1.34-21.10.1.104
! Created: UTC 2/26/2024, 3:36:54 AM
! freq[Hz]  mag:S11  ang:S11  mag:S21  ang:S21  mag:S12  ang:S12  mag:S22  ang:S22
! Worked out from all points (weakly coupled two-port):
!   5999 points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, 88.35 kHz to 500 MHz, reference 50 ohm
!   highest |S21| = -16.38 dB at 2.922 MHz (marker M1); lowest = -81.8 dB at 387 MHz (marker M2)
!   lowest |S11| = -77.6 dB at 34.68 MHz (marker M3), VSWR 1.00, Z = 50 - j0.0119 ohm
!   |S11| at or under -10 dB: 158.5 kHz to end of sweep
!   |S22| runs from -29.3 to -10.7 dB; largest |S21 - S12| = 0.22
!   S11 on the Smith chart (normalised r, x): 88.35 kHz: 0.97, +0.77; 90.44 MHz: 1.02, -0.04; 288.3 MHz: 0.78, -0.14; 500 MHz: 0.81, -0.35
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 88.35 kHz  -8.8  -44.9  -43.7  -10.7
! 2.922 MHz  -18.9  -16.4  -19.6  -18.6
! 15.92 MHz  -44.9  -39.8  -40.2  -27.1
! 34.68 MHz  -77.6  -40.7  -40.6  -27.2
! 39.51 MHz  -43.0  -40.4  -41.4  -27.5
! 83.43 MHz  -34.4  -41.6  -40.1  -27.3
! 90.44 MHz  -33.6  -40.5  -41.1  -26.5
! 166.8 MHz  -27.7  -40.5  -40.8  -26.9
! 250 MHz  -18.6  -39.7  -39.8  -27.2
! 288.3 MHz  -16.9  -38.0  -38.6  -26.8
! 302.3 MHz  -21.5  -39.5  -40.0  -26.8
! 315.5 MHz  -33.3  -42.7  -42.3  -26.9
! 333.4 MHz  -22.9  -47.4  -51.4  -27.2
! 349.8 MHz  -19.3  -60.1  -60.8  -26.6
! 357.6 MHz  -17.2  -56.5  -53.3  -25.6
! 369.2 MHz  -14.9  -52.2  -51.6  -26.3
! 375.5 MHz  -16.8  -52.7  -51.8  -26.6
! 381.8 MHz  -21.3  -63.6  -59.9  -26.5
! 387 MHz  -25.1  -81.8  -57.0  -26.6
! 398.2 MHz  -24.4  -50.7  -53.9  -25.6
! 416.7 MHz  -21.2  -48.8  -44.9  -26.3
! 500 MHz  -13.3  -35.7  -36.1  -25.5
